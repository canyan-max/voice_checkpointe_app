# Keil uVision project voice_checkpointe_app.uvprojx, settings and files
target voice_checkpointe_app (6220000::V6.22::ARMCLANG)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.7
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: voice_checkpointe_app +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AT32F435VGT7, USE_STDPERIPH_DRIVER, USE_DEBUG_LOG, LFS_DEFINES=lfs_config.h
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\00_Project_Config;..\..\01_App;..\..\02_Service;..\..\04_Impl\mcu_at32;..\..\03_Platform\bsp;..\..\03_Platform\comm;..\..\03_Platform\mcu_interface;..\..\06_Component\EasyLog\Src;..\..\06_Component\EasyLog\Inc;..\..\06_Component\Kfifo;..\..\06_Component\Minimp3;..\..\06_Component\ExternalChip\CS4344;..\..\06_Component\ExternalChip\TPA3116;..\..\06_Component\ExternalChip\VTX316;..\..\06_Component\ExternalChip\CAT5171;..\..\06_Component\ExternalChip\GT20L16S1Y;..\..\06_Component\ExternalChip\HG25Q128B;..\..\06_Component\ExternalChip\E27_D;..\..\06_Component\Button;..\..\06_Component\Protocol;..\..\06_Component\Littlefs;../../middlewares/usb_drivers/inc;../../middlewares/3rd_party/fatfs/source;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_edma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_qspi.c at32f435_437_sdio.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c diskio.c fatfs_disk.c sd_diskio.c at32_sdio.c freertos_app.c include_port.c wk_adc.c wk_i2s.c wk_qspi.c wk_sdio.c wk_spi.c wk_usart.c wk_usb_otgfs.c wk_dma.c wk_edma.c wk_gpio.c wk_i2c.c usb_app.c usbh_user.c usbh_msc_diskio.c wk_exint.c
    ../inc/: FreeRTOSConfig.h
  group 00_Project_Config
    ../../00_Project_Config/: board_at32f435_binding.h board_resources.h board_storage_layout.h
  group 01_App
    ../../01_App/: comm_app.c comm_app.h audio_playback_app.c audio_playback_app.h led_indicator_app.c sd_card_presence_app.c sd_card_presence_app.h led_indicator_app.h hub_display_app.c hub_display_app.h voice_presentation_app.c voice_presentation_app.h remote_modem_app.c remote_modem_app.h
  group 02_Service
    ../../02_Service/: audio_data_source.h audio_pcm_block.h checkpoint_config.c checkpoint_config_storage.c checkpoint_config.h audio_player_service.c audio_player_service.h audio_volume_service.c sd_card_presence_service.c sd_card_presence_service.h audio_volume_service.h mp3_decoder_service.c mp3_decoder_service.h hub_display_service.c hub_display_service.h storage_filesystem_service.c storage_filesystem_service.h remote_modem_service.c remote_modem_service.h
  group 03_Platform/bsp
    ../../03_Platform/bsp/: bsp_audio_amplifier.c bsp_audio_amplifier.h bsp_audio_output.c bsp_audio_output.h bsp_audio_volume.c bsp_audio_volume.h bsp_voice_synthesis.c bsp_voice_synthesis.h bsp_led.c bsp_sd_card.c bsp_sd_card.h bsp_led.h bsp_hub_display.c bsp_hub_display.h bsp_font_rom.c bsp_font_rom.h bsp_storage_flash.c bsp_storage_flash.h bsp_rs485.c bsp_rs485.h bsp_remote_modem.c bsp_remote_modem.h
  group 03_Platform/mcu_interface
    ../../03_Platform/mcu_interface/: plat_gpio.h plat_i2s.h plat_i2c.h plat_spi.h plat_qspi.h plat_log.h plat_resource.h plat_sys.h plat_uart.h
  group 04_Implmcu_at32
    ../../04_Impl/mcu_at32/: at32f435_gpio.c at32f435_i2s.c at32f435_i2c.c at32f435_spi.c at32f435_qspi.c at32f435_log.c at32f435_sys.c at32f435_uart.c
  group 06_Component/External_Chip
    ../../06_Component/ExternalChip/E27_D/: e27_d.c e27_d.h
    ../../06_Component/ExternalChip/CS4344/: cs4344.c cs4344.h
    ../../06_Component/ExternalChip/TPA3116/: tpa3116.c tpa3116.h
    ../../06_Component/ExternalChip/VTX316/: vtx316.c vtx316.h
    ../../06_Component/ExternalChip/CAT5171/: cat5171.c cat5171.h
    ../../06_Component/ExternalChip/GT20L16S1Y/: gt20l16s1y.c gt20l16s1y.h
    ../../06_Component/ExternalChip/HG25Q128B/: hg25q128b.c hg25q128b.h
  group 06_Component/Protocol
    ../../06_Component/Protocol/: proto_checkpoint.h proto_checkpoint.c
  group 06_Component
    ../../06_Component/Kfifo/: kfifo.c
    ../../06_Component/Minimp3/: minimp3.c
    ../../06_Component/EasyLog/Src/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
    ../../06_Component/Button/: button.c
    ../../06_Component/Littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h lfs_config.h
  group middlewares/usb_driver
    ../../middlewares/usb_drivers/src/: usb_core.c usbh_core.c usbh_int.c usbh_ctrl.c
  group usbh_class
    ../src/: usbh_msc_class.c usbh_msc_bot_scsi.c
  group middlewares/fatfs
    ../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
